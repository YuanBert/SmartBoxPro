<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MSmartBoxV1.0.ewp</path>
  </project>
  <batchBuild />
</workspace>
